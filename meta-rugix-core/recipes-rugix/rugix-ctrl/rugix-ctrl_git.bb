SRCREV = "${AUTOREV}"
PV = "0.8+git${SRCPV}"
DEFAULT_PREFERENCE = "-1"

require rugix-ctrl.inc
